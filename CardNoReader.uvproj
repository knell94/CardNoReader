# Keil uVision project CardNoReader.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CardNoReader +hex
  c flags: Optim=1
  c define: STM32F10X_MD
  c include: .\HARDWARE\KEY;.\HARDWARE\LED;.\MAIN;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\SYSTEM\usart2;.\stm32f10x
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./: STM32F10x.s
  group Main
    ./MAIN/: main.c
  group HARDWARE
    ./HARDWARE/KEY/: key.c key.h
    ./HARDWARE/LED/: led.c led.h
  group SYSTEM
    ./SYSTEM/usart2/: usart2.c usart2.h
    ./SYSTEM/usart/: usart.c usart.h
    ./SYSTEM/sys/: sys.c sys.h
    ./SYSTEM/delay/: delay.c delay.h
